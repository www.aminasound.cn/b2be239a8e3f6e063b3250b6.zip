Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-08-25T09:26:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Aug 25 09:26:30 2020* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{DCA49809-EFD3-4087-876C-F8CB5EB2536C}\ifc* Database version: 5507* Database creation date: Tue Aug 25 09:26:16 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Aug 25 09:26:30 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Aug 25 09:26:30 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: Mobius3, NBS_AminaTechnologiesLtd_Ldspkrs_Mobius3:Mobius3:307560
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: Pr_70_75_06_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AminaTechnologiesLtd_Loudspeakers_Mobius3; ManufacturerName: Amina Technologies Ltd; ManufacturerURL: https:/​/​uk.aminasound.com/​; NBSCertification: www.nationalbimlibrary.com/cert/xx1vpefg; NBSDescription: Loudspeakers; NBSReference: 90-70-10/435; ProductInformation: https://aminasound.com/file-directory/product/loudspeakers/mobius/datasheet/Mobius3_Datasheet.pdf; Revision: n/a; Uniclass2015Title: Loudspeakers; Uniclass2015Code: Pr_70_75_06_50; Uniclass2015Version: Products v1.18; Version: 1
Type - NBS_Data - LoudspeakerSensitivity: 84dB SPL (at 1m / 2.83Vrms, with 2 mm plaster skim); PowerHandlingContinuous: 30W RMS (60W Peak); EnclosureFormat: Integrated; Weight: 1.1 kg; FixingRequirements: Backbox CV300, SW300 or Mounting blocks; InLineProtectionUnit: APUi30C; UseableFrequencyRange: 80Hz – 23kHz (±10 dB); ElectricalConnection: Blue butt-splice crimp terminals (14-16 AWG); RackMountProtectionUnit: APU-RS8iC or APU-RS16iC; DispersionAngle: 180° x 180° at specified frequency range
Type - Pset_AudioVisualApplianceTypeCommon - AudioVolume: n/a; MediaSource: n/a; Reference: n/a
Type - Pset_AudioVisualApplianceTypeSpeaker - FrequencyResponse: 112Hz – 20 Hz (-6 dB); Impedence: 8 ohm (Can be supplied with high impedance 100/70V transformer); SpeakerDriverSize: n/a; SpeakerMounting: WALL; SpeakerType: FULLRANGE
Type - IFC - IfcExportAs: IfcAudioVisualApplianceType; IfcExportType: SPEAKER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_75_06_50:Loudspeakers; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: High performance fully-covered loudspeaker; DurationUnit: year; ExpectedLife: n/a; Features: Suitable for both commercial and residential applications, fully covered with 2 mm of almost any finishing material including wood, plaster, stone laminates, leather and more, completely invisible in application, exceptional dispersion, typically requiring two to four times fewer loudspeakers to cover the same space when compared to paper-cone based loudspeakers, beneficial in acoustically harsh spaces; Finish: n/a; Grade: n/a; Manufacturer: sales@aminasound.com; Material: n/a; ModelNumber: Mobius3; ModelReference: Mobius; Name: Loudspeakers_Mobius3_AminaTechnologiesLtd; NominalHeight: 400 mm; NominalLength: 300 mm; NominalWidth: 35 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 35 x 300 x 400 mm; SustainabilityPerformance: n/a; WarrantyDescription: 10 years; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: year; WarrantyGuarantorLabor: Installer; WarrantyGuarantorParts: Amina Technologies Ltd
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcDistributionPort, Port_307560
Description: Flow; FlowDirection: SOURCEANDSINK
